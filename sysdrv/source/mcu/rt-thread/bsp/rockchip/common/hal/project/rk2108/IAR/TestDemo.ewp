# IAR project TestDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR=1
  ICCARM.CCIncludePath2: ..\..\..\lib\CMSIS\Core\Include; ..\..\..\lib\CMSIS\Device\RK2108\Include; ..\..\..\lib\bsp\RK2108; ..\..\..\lib\hal\inc; ..\src; ..\..\..\test; ..\..\..\test\unity\src; ..\..\..\test\unity\extras\fixture\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: D:\rtthread\bsp\rockchip\common\hal\project\rk2108\src; D:\rtthread\bsp\rockchip\common\hal\lib\hal\inc; D:\rtthread\bsp\rockchip\common\hal\lib\CMSIS\Device\RK2108\Include
  OBJCOPY.OOCOutputFile: TestDemo.bin
  ILINK.IlinkOutputFile: TestDemo.out
  ILINK.IlinkIcfFile: D:\rtthread\bsp\rockchip\common\hal\lib\CMSIS\Device\RK2108\Source\Templates\IAR\iar_link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: hal_conf.h main.c
  group bsp
    ../../../lib/bsp/RK2108/: hal_bsp.c hal_bsp.h
  group cmsis/core
    ../../../lib/CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group cmsis/device
    ../../../lib/CMSIS/Device/RK2108/Include/: rk2108.h rk2108_usb.h soc.h system_rk2108.h
    ../../../lib/CMSIS/Device/RK2108/Source/Templates/IAR/: startup_rk2108.s
    ../../../lib/CMSIS/Device/RK2108/Source/Templates/: system_rk2108.c
  group hal/include
    ../../../lib/hal/inc/: hal_acdcdig.h hal_audio.h hal_audiopwm.h hal_base.h hal_cache.h hal_cru.h hal_crypto.h hal_debug.h hal_def.h hal_demo.h hal_display.h hal_dma.h hal_driver.h hal_dsi.h hal_dsp.h hal_dwdma.h hal_efuse.h hal_fspi.h hal_gpio.h hal_hcd.h hal_hwspinlock.h hal_hyperpsram.h hal_i2c.h hal_i2s.h hal_i2stdm.h hal_intc.h hal_keyctrl.h hal_list.h hal_math.h hal_mbox.h hal_nvic.h hal_pcd.h hal_pcd_ex.h hal_pd.h hal_pdm.h hal_pinctrl.h hal_pl330.h hal_pm.h hal_pvtm.h hal_pwm.h hal_pwr.h hal_qpipsram.h hal_saradc.h hal_sdio.h hal_sfc.h hal_snor.h hal_spi.h hal_spi2apb.h hal_spi_mem.h hal_spinand.h hal_systick.h hal_textrw.h hal_timer.h hal_touchkey.h hal_tsadc.h hal_uart.h hal_usb_core.h hal_usb_phy.h hal_vad.h hal_vicap.h hal_vop.h hal_wdt.h
  group hal/source
    ../../../lib/hal/src/: hal_acdcdig.c hal_acdcdigv2.c hal_audiopwm.c hal_base.c hal_base_ex.c hal_cache.c hal_debug.c hal_demo.c hal_dwdma.c hal_efuse.c hal_fspi.c hal_gpio.c hal_hcd.c hal_hwspinlock.c hal_hyperpsram.c hal_i2c.c hal_i2s.c hal_i2stdm.c hal_keyctrl.c hal_mbox.c hal_nvic.c hal_pcd.c hal_pcd_ex.c hal_pd.c hal_pdm.c hal_pinctrl.c hal_pinctrl_v2.c hal_pl330.c hal_pvtm.c hal_pwm.c hal_pwr.c hal_qpipsram.c hal_saradc.c hal_sdio.c hal_sfc.c hal_snor.c hal_spi.c hal_spi2apb.c hal_spinand.c hal_systick.c hal_timer.c hal_touchkey.c hal_tsadc.c hal_uart.c hal_usb_core.c hal_usb_phy.c hal_vad.c hal_vicap.c hal_wdt.c
  group hal/source/cru
    ../../../lib/hal/src/cru/: hal_cru.c hal_cru_rk2108.c
  group hal/source/display
    ../../../lib/hal/src/display/: hal_dsi.c hal_vop_rk2108.c
  group hal/source/dsp
    ../../../lib/hal/src/dsp/: hal_dsp_rk2108.c
  group test
    ../../../test/: unity_config.h unity_port.c unity_runner.c unity_runner.h
  group test/test_case
    ../../../test/hal/: test_cru.c test_leagacy.c test_pd.c test_pl330.c test_snor.c test_timer.c
  group test/test_case/psram
    ../../../test/hal/psram/: test_hyper_cru.c test_hyper_cru.h test_hyperpsram.c test_hyperpsram.h test_psram.c test_psram.h test_qpipsram.c
  group test/unity/extras/fixture/src
    ../../../test/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group test/unity/src
    ../../../test/unity/src/: unity.c unity.h unity_internals.h
