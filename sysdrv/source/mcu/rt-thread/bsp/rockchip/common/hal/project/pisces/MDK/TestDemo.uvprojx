# Keil uVision project TestDemo.uvprojx, settings and files
target Pisces (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: TestDemo
  AfterMake: fromELF --bin -o TestDemo.bin  .\Objects\TestDemo.axf
  c flags: wLevel=1
  c misc: --c99 --gnu
  c include: ..\src;..\..\..\lib\hal\inc;..\..\..\lib\CMSIS\Core\Include;..\..\..\lib\CMSIS\Device\Pisces\Include;..\..\..\lib\CMSIS\Device;..\..\..\test\unity;..\..\..\test\unity\src;..\..\..\test\unity\extras\fixture\src;..\..\..\test;..\..\..\test\coremark;..\..\..\test\coremark\barebones;..\..\..\lib\bsp\Pisces
  library: MicroLIB
  memory RVCT4: ROM 0x4000000 size 0x20000
  memory RVCT9: RAM 0x4020000 size 0x20000
  scatter file: ..\..\..\lib\CMSIS\Device\Pisces\Source\Templates\ARM\pisces_ac5.sct
  group Device
    ../../../lib/CMSIS/Device/Pisces/Source/Templates/: system_pisces.c
    ../../../lib/CMSIS/Device/Pisces/Source/Templates/ARM/: startup_pisces.s
  group USER
    ../src/: main.c
  group HAL
    ../../../lib/hal/src/: hal_base.c hal_nvic.c hal_uart.c hal_gpio.c hal_grf.c hal_timer.c hal_debug.c hal_cru.c hal_demo.c hal_mbox.c hal_pd.c hal_pl330.c hal_pm.c hal_vop.c hal_wdt.c
  group UNITY
    ../../../test/: unity_port.c unity_runner.c
    ../../../test/hal/: test_timer.c test_snor.c test_pl330.c test_cru.c test_leagacy.c test_pd.c
    ../../../test/unity/src/: unity.c
    ../../../test/unity/extras/fixture/src/: unity_fixture.c
  group COREMARK
    ../../../test/coremark/: core_util.c core_state.c core_matrix.c core_main.c core_list_join.c
    ../../../test/coremark/barebones/: core_portme.c ee_printf.c cvt.c
  group BSP
    ../../../lib/bsp/Pisces/: bsp.c
